## boards/arm/pawpaw/Kconfig.board
```kconfig
# Skree Pawpaw board configuration
# SPDX-License-Identifier: MIT

config BOARD_PAWPAW
    bool "Skree Pawpaw"
    depends on SOC_NRF52840_QIAA
```
